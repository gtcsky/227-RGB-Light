# Keil uVision project BG227_B RGB Light.uvprojx, settings and files
target BG 227 RGB Light (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: BG227 RGB Light +hex
  c flags: Optim=1 OneElfS=1
  c misc: --c99
  c include: ..\mcu\common;..\source;..\driver\inc;..\source\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l136.s
    ../mcu/common/: system_hc32l136.c
  group source
    ../source/src/: main.c user_pca.c user_sysctrl.c user_color.c user_lptimer.c user_key.c user_menu.c user_exti.c user_adc.c user_spi.c user_lcd.c user_i2c.c user_lightEffect.c user_lvr.c user_watchdog.c
  group driver
    ../driver/src/: ddl.c gpio.c lpm.c pca.c sysctrl.c interrupts_hc32l136.c flash.c lpt.c adc.c bgr.c spi.c i2c.c bt.c lvd.c wdt.c uart.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
